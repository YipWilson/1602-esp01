# Keil uVision project 1602.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STM32F103xE
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD1602;..\HARDWARE\TIMER;..\HARDWARE\key;..\HARDWARE\buzz;..\HARDWARE\Gizwits;..\HARDWARE\Utils;..\HARDWARE\RTC;..\HARDWARE\DHT11;..\HARDWARE\AT;..\HARDWARE\ATcall;..\HARDWARE\usart3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD1602/: lcd1602.c
    ../HARDWARE/TIMER/: timer.c timemodu.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/buzz/: buz.c
    ../HARDWARE/Utils/: common.c dataPointTools.c ringbuffer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/AT/: AT_ESP.c
    ../HARDWARE/ATcall/: ATcall.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/usart3/: bsp_usart3.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
